# Keil uVision project midi_music_stm32f4.uvprojx, settings and files
target proj (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: midi_music_stm32f4
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1,__CC_ARM,ARM_MATH_ROUNDING
  c include: ..\midi_music_stm32f4;.\CMSIS;.\CMSIS\STARTUP;.\FWLIB\src;.\FWLIB\inc;.\Components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: arm_common_tables.h arm_const_structs.h arm_cortexM4lf_math.lib arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx_it.c system_stm32f4xx.c
    ./CMSIS/STARTUP/: startup_stm32f411xe.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ./Components/delay/: delay.c
    ./Components/led/: led.c
    ./Components/timer/: timer.c
    ./Components/uart/: uart1.c uart2.c
    ./Components/tone/: tone.c
    ./Components/midi/: midi.c
    ./Components/i2c_slave/: i2c_slave.c
    ./Components/status/: status.c
  group MAIN
    ./: main.c stm32f4xx.h stm32f4xx_conf.h
